# Keil uVision project TFT SSD1289 STM32 Driver Code.uvproj, settings and files
target TFT SSD1289 STM32 Driver (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: TFT SSD1289 STM32 Driver +hex
  c flags: Optim=1
  c define: STM32F10X_XL,USE_STDPERIPH_DRIVER
  c include: .\Source\FWLib\inc;.\Source\Startup;.\Source\APP;.\Source\LCDDriver;.\Source\Run
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ./Source/Startup/: startup_stm32f10x_xl.s core_cm3.c
  group APP
    ./Source/APP/: stm32f10x_it.c system_stm32f10x.c USART.c TIM.c ADC.c PWM.c GPS.c
  group LCDDriver
    ./Source/LCDDriver/: ili9320_api.c ili9320.c
  group FWLib
    ./Source/FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group New Group
    ./Source/Run/: init.c main.c
